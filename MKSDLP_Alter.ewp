# IAR project MKSDLP_Alter.ewp, settings and files
configuration MKSDLP_Alter_debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG__; USE_HAL_DRIVER; STM32F407xx; USE_HAL_SPI_REGISTER_CALLBACKS=1U; MKS_DLP_BOARD
  ICCARM.CCDiagSuppress: Pe009
  ICCARM.CCIncludePath2: src/App; src/App/tft; src/App/tgui; src/App/stepper; src/App/uvdisplay; src/App/prtfiles; src/FATFS/Target; src/FATFS/App; src/USB_HOST/App; src/USB_HOST/Target; src/Drivers/STM32F4xx_HAL_Driver/Inc; src/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; src/Middlewares/Third_Party/FatFs/src; src/Middlewares/ST/STM32_USB_Host_Library/Core/Inc; src/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; src/Drivers/CMSIS/Device/ST/STM32F4xx/Include; src/Drivers/CMSIS/Include; src/System
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: mksDLP.bin
  ILINK.IlinkOutputFile: mksDLP.out
  ILINK.IlinkIcfFile: config/stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: history.txt settings.acfg
    ./: README.md
  group __ORIGINAL_SOURCES__
    ../../MKS-DLP-FIRMWARE-master/Src/: cpld.c mks_dlp_main.cpp mks_reprint.cpp spi.c
    ../../MKS-DLP-FIRMWARE-master/Drivers/BSP/Components/w25qxx/: spi_flash.c spi_flash.h w25qxx.c
    ../../MKS-DLP-FIRMWARE-master/Drivers/BSP/Components/SSD2828/: ssd2828.cpp ssd2828.h
  group Application
    src/App/: fsmc.c fst_spi.c gpio.c main.cpp printing.cpp
  group Application/CONFIG
    src/App/: config.cpp eeprom.cpp
  group Application/FATFS/App
    src/FATFS/App/: fatfs.c
  group Application/FATFS/Target
    src/FATFS/Target/: spifl_diskio.c usbh_diskio.c
  group Application/LCD_UI
    src/App/tft/: lcd_low.c lcd_ui.cpp
    src/App/: unicode_utils.cpp
  group Application/LCD_UI/fonts
    src/App/tft/fonts/: fnt12.c fnt12bold.c fnt170num_lcd.c fnt18.c fnt18bold.c fnt24.c fnt24bold.c fnt36.c fnt36num.c
  group Application/PRT_FILES
    src/App/prtfiles/: files_photon.cpp files_pws.cpp prtfiles.cpp
  group Application/SPI FLASH
    src/App/: spi_flash.c
  group Application/STEPPER
    src/App/stepper/: motor.cpp z_endstops.cpp z_planner.cpp z_stepper.cpp
  group Application/STEPPER/_orig
    src/App/stepper/: endstops.cpp planner.cpp stepper.cpp
    ../../MARLIN_NEW/Marlin-2.0.x/Marlin/src/gcode/motion/: G0_G1.cpp
    ../../MARLIN_NEW/Marlin-2.0.x/Marlin/src/: MarlinCore.cpp
    ../../MARLIN_NEW/Marlin-2.0.x/Marlin/src/module/: motion.cpp
  group Application/TIMERS
    src/App/: datetime.cpp rtc.c sys_timer.c tim.c
  group Application/TOUCH GUI
    src/App/tgui/: languages.cpp tgui.cpp tgui_clocksetscreenfuncs.cpp tgui_defaultfuncs.cpp tgui_filesscreenfuncs.cpp tgui_fileviewscreenfuncs.cpp tgui_infoscreenfuncs.cpp tgui_langscreenfuncs.cpp tgui_mainscreenfuncs.cpp tgui_messagebox.cpp tgui_movezscreenfuncs.cpp tgui_numenterscreenfuncs.cpp tgui_printscreenfuncs.cpp tgui_prnparamsscreenfuncs.cpp tgui_screensaverfuncs.cpp tgui_settingsscreenfuncs.cpp tgui_uvtestscreenfuncs.cpp
    src/App/tft/: touch.c
  group Application/UV_DISPLAY
    src/App/uvdisplay/: cpld_utils.cpp ssd_utils.cpp uvdisplay.cpp
  group Application/UV_DISPLAY/orig
    src/App/uvdisplay/orig/: _main.cpp fastio_dlp_board.h mks_dlp_main.cpp mks_reprint.cpp ssd2828.cpp ssd2828.h
  group Config
    config/: stm32f407xx_flash.icf
    src/System/: stm32f4xx_hal_conf.h
  group Drivers/CMSIS
    ../../MKS-DLP-FIRMWARE-master/Drivers/libstmf4/source/: stm32f4xx_i2c.c
    ../../MKS-DLP-FIRMWARE-master/Drivers/libstmf4/include/: stm32f4xx_i2c.h
    src/System/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    src/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs
    src/Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c
    src/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group Middlewares/USB_Host_Library
    src/USB_HOST/App/: usb_host.c
    src/USB_HOST/Target/: usbh_conf.c usbh_platform.c
    src/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    src/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group System
    src/System/: startup_stm32f407xx.s stm32f4xx_hal_msp.c stm32f4xx_it.c
