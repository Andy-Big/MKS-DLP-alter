<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MKS_DLP_new.ewp</path>
  </project>
  <batchBuild />
</workspace>
